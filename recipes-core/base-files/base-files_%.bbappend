FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

DISTRO_VERSION[vardeps] += "DISTRO_EXTRA_VERSION"
